Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-11-10T17:38:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 10 17:38:34 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\f20bdbb5-a352-4912-964d-7b0e7567037a\0d1ceeb9-510f-44cf-a89b-7b60d7afebe9\ifc * Database version: 5507 * Database creation date: Mon Nov 10 17:38:34 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 10 17:38:34 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 10 17:38:34 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6895, Emenda_6894_6895_Nordecor:6895:329166
In: Nível 1
Type - Material: Metal - Alumínio - Preto
Type - Cotas - Comprimento 01: 97.48 mm; Comprimento 02: 97.48 mm
Type - Dados - Data de atualização: 31/10/2025; Versão: 1
Type - Dados de identidade - Código Uniformat: D5020; Comentários de tipos: emenda 90°, trilho FINE, conector de embutir, junção angular, parede, acabamento branco, acabamento preto, acessório de instalação; Contato do desenvolvedor: "contato@checkbim.com.br"; Contato do fabricante: comercial@nordecor.com.br; Descrição: Emenda 90º de embutir para parede para trilho FINE acabamento preto; Descrição UniFormat: Iluminação e acessórios elétricos / Lighting and Electrical Accessories; Desenvolvedor: "Check BIM"; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú-SC / Brasil; Modelo: 6895; Nome do tipo: 6895; Nota-chave: 26 50 00; Número MasterFormat: 26 51 00; Número OmniClass: 23.80.70.11; Tipo de imagem: Imagem raster: 6895.jpg; Tipo de luminária: Acessório / Accessory; Título MasterFormat: Interior Lighting; Título OmniClass: Luminaries for Internal Lighting; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/
Type - Estrutural - Peso da luminária: 0
Type - Gráficos - Simbologia: Imagem raster: 6895 2D.png
Type - Materiais e acabamentos - Emenda "L": Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Branco: no; Nome da família: Emenda_6894_6895_Nordecor; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6895; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.00715365 m2; Volume: 0.0000158737 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Emenda_6894_6895_Nordecor: 6895; Família e tipo: Emenda_6894_6895_Nordecor: 6895; ID de tipo: Emenda_6894_6895_Nordecor: 6895; Tipo: Emenda_6894_6895_Nordecor: 6895
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
